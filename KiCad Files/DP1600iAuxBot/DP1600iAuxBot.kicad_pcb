# Repository Hocus-Pocus/Speeduino-DP1600i-

File README.md:

# Speeduino-DP1600i-
This is an expanded version of Buggly SPD. It offers the user some options and a proto area if more features than the Buggly SPD board has are desired

WORK IN PROGRESS

## KiCad design KiCad Files/DP1600iAuxBot/DP1600iAuxBot.kicad_pcb

Parts:
C1: 0.01uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18X7R1H103KNU06; Digikey Part Number 445-174244-1-ND
C2: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18X8R1E104KNU06; Digikey Part Number 445-180563-1-ND
D1, D3: 1N5818; D_DO-41_SOD81_P10.16mm_Horizontal
D2, D4: 1N5231B; D_DO-41_SOD81_P10.16mm_Horizontal
IC1: Trig Cond Socket; DIP-8_W7.62mm_Socket
J1: DB25_Female; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_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
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J4: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J5: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J6: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
JP1, JP2: PULL-UP; PinHeader_1x02_P2.54mm_Vertical; Manufacturer_Part_Number M20-9990245; Digikey Part Number 952-2261-ND
JP3: VR-HALL; PinHeader_1x03_P2.54mm_Vertical; Manufacturer_Part_Number M20-9990345; Digikey Part Number 952-2263-ND
JP4: HALL-VR; PinHeader_1x03_P2.54mm_Vertical; Manufacturer_Part_Number M20-9990345; Digikey Part Number 952-2263-ND
JP5, JP7: EN-DIS; PinHeader_1x03_P2.54mm_Vertical; Manufacturer_Part_Number M20-9990345; Digikey Part Number 952-2263-ND
JP6: DIS-EN; PinHeader_1x03_P2.54mm_Vertical; Manufacturer_Part_Number M20-9990345; Digikey Part Number 952-2263-ND
Q1: 2N3906; TO-92_Inline_Wide; MPN 2N3906; Digi-Key_PN 2N3906CS-ND
R1: 24K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 4.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14, R15: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C1001FRP00; Digikey Part Number BC1.00KXCT-ND

Connections:
12V-Raw: J1.13, J5.2
CKP+: J6.3, JP1.1 (A), JP3.2 (C)
CKP-: IC1.1, J6.4
CLT_Sensor: J1.15, J5.6
CMP+: J2.1, JP2.1 (A), JP4.2 (C)
CMP-: J2.2, JP6.2 (C)
D8-control: J1.25, J6.8
D9-control: J1.12, J6.7
D10-control: J1.24, J4.3
D11-control: J1.11, J4.4
D12-control: J1.23, J6.6
D13-control: J1.10, J4.2
D48-control: J1.22, J4.1
D49-control: J1.9, R2.1
D50-control: J1.21, J6.10
D51-control: J1.8, J6.9
D52-control: J1.20, J4.5
D53-control: J1.7, J4.6
F9-out: J6.5, Q1.1 (E), R1.2
GND: C1.1, C2.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), IC1.6, J1.5, J1.18, J3.1, J3.2, J3.3, J6.1, J6.2, JP5.3 (B), JP6.1 (A), JP7.3 (B)
IAT_Sensor: J1.3, J5.5
MCU-D18: C2.2, D3.1 (K), D4.1 (K), J1.6, JP4.3 (B), JP7.1 (A)
MCU-D19: C1.2, D1.1 (K), D2.1 (K), IC1.8, J1.19, JP3.3 (B)
unnamed: IC1.2, JP3.1 (A)
unnamed: IC1.3, JP5.2 (C)
unnamed: IC1.4, JP6.3 (B)
unnamed: IC1.7, JP7.2 (C)
unnamed: JP1.2 (B), R14.1
unnamed: JP2.2 (B), R15.1
unnamed: JP4.1 (A), JP5.1 (A)
unnamed: Q1.2 (B), R1.1, R2.2
unnamed: Q1.3 (C), R3.2
O2_Sensor: J1.14, J5.8
SigRtn: J1.16, J5.4
Spare-ADC: J1.1, J5.9
TPS_Sensor: J1.2, J5.7
Tachometer: J5.1, R3.1
VDD: IC1.5, J1.17, R14.2, R15.2
VDDA: J1.4, J5.3

Notes on the sheet:
Crank Angle Sensor conditioner
Cam Angle Sensor conditioner
(Sinking Transistor PWM Output from ULN2003)
(12 volt square wave signal to tachometer & LED)
DB25 connections to DP1600i board
Crank VR sensor +
Crank VR sensor -
12 volt from main relay
Inj1
Inj2
Inj3
Inj4
PWM Idle
Spare high current output
ASD relay control
Tachometer signal
Ign1
Ign2
Ign3
Ign4
CKP input
CMP input
Common ground
5 volt
Sensor ground
Spare ADC
Throttle Position Sensor
Wide Band O2 sensor
Cylinder head temperaure
Inlet Air Temperature
5 Volt ADC
Tach & WB & Idle +
Tachometer driver circuit
Header sockets connections to DP1660iAuxTop board
DIP8 sized socket pair will accept conditioner modules from WTMotronics, JB Perf V2.1, and possibly others that use the MAX9926 chip.
(Pin defaults low. Goes high after boot sequence, goes low at start of coil dwell, goes Hi after end of coil dwell.)
CMP Enable/Disable
Optional

Board: 2 copper layers, 120.4 x 100.1 mm, 26 parts (0 on the bottom side), 39 nets.

## KiCad design KiCad Files/DP1600i/DP1600i.kicad_pcb

Board: 2 copper layers, 120.4 x 100.1 mm, 123 parts (0 on the bottom side), 89 nets.

Parts:
C1, C2, C5, C6, C11, C12, C13, C19, C21, C23: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C26: .01uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C4, C27: 1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C7, C8, C14, C15, C16, C24: 0.22uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C9, C10: 47pf; C_Disc_D5.0mm_W2.5mm_P2.50mm
C17, C25: 0.01uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C18: 10uF; CP_Radial_D5.0mm_P2.00mm
C20: 22uF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C22: 47uF; CP_Radial_D8.0mm_P5.00mm
D1, D3, D5, D7, D9, D11, D13, D15, D17: 1N5818; D_DO-41_SOD81_P10.16mm_Horizontal
D2, D4, D6, D8, D10, D12, D16, D18: 1N5231B; D_DO-41_SOD81_P10.16mm_Horizontal
F1: MF-R050; Fuse_BelFuse_0ZRE0100FF_L18.7mm_W5.1mm
J1: DB25_Male; DSUB-25_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Ho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
J2: 12V Test; Jumper-Pad
J3: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J4, J9: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J5: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J6: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J7: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J8: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J87: Pin D4; Jumper-Pad
J88: Pin D3; Jumper-Pad
J89: Pin D2; Jumper-Pad
J90: Pin D1; Jumper-Pad
J91: Pin D0; Jumper-Pad
J92: D7 out; Jumper-Pad
J93: D6 out; Jumper-Pad
J94: D5 out; Jumper-Pad
J95: Step 2B; Jumper-Pad
J96: Step 2A; Jumper-Pad
J97: Step 1A; Jumper-Pad
J98: Step 1B; Jumper-Pad
JP1: Jumper_NO_Small; PinHeader_1x02_P2.54mm_Vertical
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 3.9k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4, R9, R10, R11, R14: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6: 51K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R8: 2.49k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 120R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15, R16, R17, R18, R19, R20, R21, R22, R23, R24: 22R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R25, R26, R27, R28, R29, R30, R37, R38, R39, R40: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R31, R32, R33, R34, R35, R36, R41, R42, R43, R44: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: ERZ-V14D220; RV_Disc_D15.5mm_W4.7mm_P7.5mm
U1, U2: MPXH6115_Adapter_Vertical
U3: LM2940T-5.0; TO-220-3_Horizontal_TabDown
U4, U5, U6, U7, U8: IXDNI604PI; DIP-8_W7.62mm
U9: ULN2004AN; DIP-16_W7.62mm
U10: A4988StepStick

Connections:
5V-Drivers: C3.2, C4.2, C21.1, C22.1, F1.2, J1.17, J6.1, J6.2, J8.3, R12.2, R13.2, U3.3, U5.6, U7.6, U10.10
12V: C18.1, C19.1, C26.2, C27.2, D13.1, J2.1, R2.2, U3.1, U4.6, U6.6, U8.6, U9.9, U10.16
12V-Raw: D13.2, J1.13, RV1.1
ADC-Clamp-2: C8.1, D5.1, D6.1, J9.3, R4.1
ADC-Clamp-3: C15.1, D1.1, D2.1, J9.4, R10.1
ADC-Clamp-4: C16.1, D9.1, D10.1, J9.5, R11.1
ADC-Clamp-5: C14.1, D3.1, D4.1, J9.6, R9.1
ADC-Clamp-6: C24.1, D15.1, D16.1, J9.7, R14.1
ADC-Clamp-7: C7.1, D7.1, D8.1, J9.8, R3.1
CLT_Sensor: C13.1, J1.15, R8.1, R11.2
Clamp-18: C25.2, D11.1, D12.1, J1.6, J5.3
Clamp-19: C17.2, D17.1, D18.1, J1.19, J5.4
D8-control: J1.25, R15.1
D9-control: J1.12, R17.1
D10-control: J1.24, R19.1
D11-control: J1.11, R21.1
D12-control: J1.23, R23.1
D13-control: J1.10, R24.1
D48-control: J1.22, U9.11
D49-control: J1.9, U9.10
D50-control: J1.21, R16.1
D51-control: J1.8, R18.1
D52-control: J1.20, R20.1
D53-control: J1.7, R22.1
GND: C3.1, C4.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C25.1, C26.1, C27.1, D11.2, D12.2, D17.2, D18.2, J1.5, J1.18, J3.1, J7.7, J7.8, J8.4, J8.5, JP2.2, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R37.1, R38.1, R39.1, R40.1, RV1.2, U3.2, U4.3, U5.3, U6.3, U7.3, U8.3, U9.8, U10.9, U10.15
IAT_Sensor: C12.1, J1.3, R7.1, R10.2
MCU-A0: C10.1, J9.1, R6.1
MCU-A1: C9.1, J9.2, R5.1
MCU-D0: J4.8, J91.1
MCU-D1: J4.7, J90.1
MCU-D2: J4.6, J89.1
MCU-D3: J4.5, J88.1
MCU-D4: J4.4, J87.1
MCU-D5: J4.3, U9.5
MCU-D6: J4.2, U9.4
MCU-D7: J4.1, U9.3
MCU-D8: J3.7, R25.2, R31.2
MCU-D9: J3.6, R26.2, R32.2
MCU-D10: J3.5, R27.2, R33.2
MCU-D11: J3.4, R28.2, R34.2
MCU-D12: J3.3, R29.2, R35.2
MCU-D13: J3.2, R30.2, R36.2
MCU-D16: J5.1, U10.8
MCU-D17: J5.2, U10.7
MCU-D24: J6.5, U10.1
MCU-D48: J7.1, U9.6
MCU-D49: J7.2, U9.7
MCU-D50: J7.3, R37.2, R41.2
MCU-D51: J7.4, R38.2, R42.2
MCU-D52: J7.5, R39.2, R43.2
MCU-D53: J7.6, R40.2, R44.2
unnamed: C6.1, R1.2, R2.1, R4.2
unnamed: C20.1, JP1.1, R13.1
unnamed: J92.1, U9.14
unnamed: J93.1, U9.13
unnamed: J94.1, U9.12
unnamed: J95.1, U10.14
unnamed: J96.1, U10.13
unnamed: J97.1, U10.12
unnamed: J98.1, U10.11
unnamed: R5.2, U1.4
unnamed: R6.2, U2.4
unnamed: R15.2, U4.7
unnamed: R16.2, U5.7
unnamed: R17.2, U4.5
unnamed: R18.2, U5.5
unnamed: R19.2, U6.7
unnamed: R20.2, U7.7
unnamed: R21.2, U6.5
unnamed: R22.2, U7.5
unnamed: R23.2, U8.7
unnamed: R24.2, U8.5
unnamed: R31.1, U4.2
unnamed: R32.1, U4.4
unnamed: R33.1, U6.2
unnamed: R34.1, U6.4
unnamed: R35.1, U8.2
unnamed: R36.1, U8.4
unnamed: R41.1, U5.2
unnamed: R42.1, U5.4
unnamed: R43.1, U7.2
unnamed: R44.1, U7.4
unnamed: U10.5, U10.6
O2_Sensor: C5.1, J1.14, R3.2
RESET: J8.1, JP1.2, R12.1
SigRtn: C1.1, C2.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C23.2, C24.2, D1.2, D2.2, D3.2, D4.2, D5.2, D6.2, D7.2, D8.2, D9.2, D10.2, D15.2, D16.2, J1.16, JP2.1, R1.1, U1.3, U2.3
Spare-ADC: C23.1, J1.1, R14.2
TPS_Sensor: C11.1, J1.2, R9.2
VDDA: C1.2, C2.2, F1.1, J1.4, R7.2, R8.2, U1.2, U2.2

## KiCad design KiCad Files/DP1600iAuxTop/DP1600iAuxTop.kicad_pcb

Parts:
D1, D2, D14, D15, D16, D17, D18, D19, D20, D30, D31, D32, D33: LED; LED_D5.0mm
D8, D9, D10, D11, D12, D13, D21, D26, D27, D28, D29, D34: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
F1: 20A; 01530008Z_Fuse_Holder
F2: RXEF135-1; Fuse_Bourns_MF-RHT750
F3, F4, F5, F6, F7, F8, F9: 10A; 01530008Z_Fuse_Holder
J1: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J13: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J20: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J23: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J30: Screw_Terminal_01x02; Phoenix_1714955
J31: Screw_Terminal_01x08; Phoenix_1729076_Rt
J32: Screw_Terminal_01x07; Phoenix_1729063_Rt
J33, J35: Screw_Terminal_01x02; Phoenix_1730010
J34: Screw_Terminal_01x06; Phoenix_1715190
J36: Screw_Terminal_01x07; Phoenix_1729063
K1: Main; VCF4-1000
K2: Automatic Shut Down; VCF4-1000
Q1, Q2, Q3, Q4, Q5, Q6: AUIRF3205; TO-220-3_Vertical_Wide
Q7, Q8, Q9, Q10: ISL9V3040P3; TO-220-3_Vertical_Wide
R1: 2.4K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R8, R9, R10, R11, R12, R13, R19, R20, R21, R22: 2.4k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 2.4K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1: R_Network03_US; R_Array_SIP4
RN2: R_Pack02_SIP; R_Array_SIP4

Connections:
12V-Raw: F2.1, J23.2, R18.1
Bat+: F1.2, J30.2
Bat+s: D21.1 (K), J31.1, K1.86
CKP+: J1.3, J32.6
CKP-: J1.4, J32.7
CLT-Sensor: J23.6, J36.4
CMP+: J5.1, J35.1
CMP-: J5.2, J35.2
D8-control: J1.8, Q3.1 (G), RN2.2 (R1.2)
D8-out: D10.1 (A), J32.1, Q3.2 (D), R10.1
D9-control: J1.7, Q4.1 (G), RN2.3 (R2.1)
D9-out: D11.1 (A), J32.3, Q4.2 (D), R11.1
D10-control: J13.3, Q5.1 (G), RN1.3 (R2)
D10-out: D12.1 (A), J34.3, Q5.2 (D), R12.1
D11-control: J13.4, Q6.1 (G), RN1.4 (R3)
D11-out: D13.1 (A), J34.4, Q6.2 (D), R13.1
D12-control: J1.6, Q1.1 (G)
D12-out: D8.1 (A), J32.2, Q1.2 (D), R8.1
D13-control: J13.2, Q2.1 (G), RN1.2 (R1)
D13-out: D9.1 (A), J34.2, Q2.2 (D), R9.1
D48-control: D34.2 (A), J13.1, K2.85
D50-control: J1.10, Q7.1 (G)
D50-out: D26.1 (A), J31.7, Q7.2 (C), R19.1
D51-control: J1.9, Q8.1 (G)
D51-out: D28.1 (A), J31.8, Q8.2 (C), R20.1
D52-control: J13.5, Q9.1 (G)
D52-out: D27.1 (A), J34.5, Q9.2 (C), R21.1
D53-control: J13.6, Q10.1 (G)
D53-out: D29.1 (A), J34.6, Q10.2 (C), R22.1
F3-out: D9.2 (K), D15.1 (A), F3.2, J33.1
F4-out: D27.2 (K), D29.2 (K), D32.1 (A), D33.1 (A), F4.2, J33.2
F5-out: D12.2 (K), D13.2 (K), D18.1 (A), D19.1 (A), F5.2, J34.1
F6-out: D10.2 (K), D11.2 (K), D16.1 (A), D17.1 (A), F6.2, J31.6
F7-out: D26.2 (K), D28.2 (K), D30.1 (A), D31.1 (A), F7.2, J31.5
F8-out: F8.2, J31.4
F9-out: D8.2 (K), D14.1 (A), F9.2, J1.5, J31.2, J31.3
GND: D1.2 (K), D2.2 (K), D20.2 (K), D21.2 (A), J1.1, J1.2, J20.1, J20.2, J20.3, J30.1, J32.5, K1.85, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (E), Q8.3 (E), Q9.3 (E), Q10.3 (E), RN1.1 (common), RN2.1 (R1.1), RN2.4 (R2.2)
IAT-Sensor: J23.5, J36.3
unnamed: D1.1 (A), R7.1
unnamed: D2.1 (A), R1.2
unnamed: D14.2 (K), R8.2
unnamed: D15.2 (K), R9.2
unnamed: D16.2 (K), R10.2
unnamed: D17.2 (K), R11.2
unnamed: D18.2 (K), R12.2
unnamed: D19.2 (K), R13.2
unnamed: D20.1 (A), R18.2
unnamed: D30.2 (K), R19.2
unnamed: D31.2 (K), R20.2
unnamed: D32.2 (K), R21.2
unnamed: D33.2 (K), R22.2
unnamed: D34.1 (K), F2.2, K1.87, K2.30, K2.86
unnamed: F1.1, K1.30
unnamed: F3.1, F4.1, F5.1, F6.1, F7.1, F8.1, F9.1, K2.87, R1.1
O2-Sensor: J23.8, J36.6
SigRtn: J23.4, J36.2
Spare-ADC: J23.9, J36.7
TPS-Sensor: J23.7, J36.5
Tachometer: J23.1, J32.4, R7.2
VDDA: J23.3, J36.1

Notes on the sheet:
YlGn
Inj1 & Inj2 +
Inj3 & Inj4 +
Ign1 & Ign2 +
Ign3 & Ign4 +
WB & Tach & PWM Idle +
(Ign1)
(Inj1)
(Ign2)
(Ign3)
(Ign4)
(Inj2)
(Inj3)
(Inj4)
(PWM Idle)
(Spare out)
Flyback
Battery negative
Battery positive
Battery switched start & run
Tachometer signal
Tach & WB & Idle +
Fuel Pump +
Inj1
Inj2
Ign1
Ign2
Inj3
Inj4
Ign3
Ign4
IAT
CLT
ADC Gnd
TPS
ADC 5V
WB O2
Spare ADC
CKP VR+
CKP VR-

Board: 2 copper layers, 120.4 x 99.9 mm, 73 parts (0 on the bottom side), 60 nets.

## KiCad design KiCad Files/Speeduino Pin Test/Speeduino Pin Test Board.kicad_pcb

Parts:
J1, J3: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J2: Conn_02x20_Counter_Clockwise; PinHeader_2x20_P2.54mm_Vertical_CW

Connections:
GND: J1.9, J1.10, J2.9, J2.10, J2.23, J3.18
unnamed: J1.1, J2.1
unnamed: J1.2, J2.2
unnamed: J1.3, J2.3
unnamed: J1.4, J2.4
unnamed: J1.5, J2.5
unnamed: J1.6, J2.6
unnamed: J1.7, J2.7
unnamed: J1.8, J2.8
unnamed: J1.11, J2.11
unnamed: J1.12, J2.12
unnamed: J1.13, J2.13
unnamed: J1.14, J2.14
unnamed: J1.15, J2.15
unnamed: J1.16, J2.16
unnamed: J1.17, J2.17
unnamed: J1.18, J2.18
unnamed: J1.19, J2.19
unnamed: J1.20, J2.20
unnamed: J2.21, J3.20
unnamed: J2.22, J3.19
unnamed: J2.24, J3.17
unnamed: J2.25, J3.16
unnamed: J2.26, J3.15
unnamed: J2.27, J3.14
unnamed: J2.28, J3.13
unnamed: J2.29, J3.12
unnamed: J2.30, J3.11
unnamed: J2.31, J3.10
unnamed: J2.32, J3.9
unnamed: J2.33, J3.8
unnamed: J2.34, J3.7
unnamed: J2.35, J3.6
unnamed: J2.36, J3.5
unnamed: J2.37, J3.4
unnamed: J2.38, J3.3
unnamed: J2.39, J3.2
unnamed: J2.40, J3.1

Board: 2 copper layers, 24.1 x 53.3 mm, 3 parts (0 on the bottom side), 38 nets.

## KiCad design KiCad Files/Single VR Conditioner/Single VR Conditioner.kicad_pcb

Schematic: Single VR Conditioner.sch, Buggly Gruesome Single VR Conditioner

Parts:
C1: 330pf; C_Rect_L7.2mm_W4.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C2: .33uf; C_Rect_L7.2mm_W4.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C3: .1uf; C_Rect_L7.2mm_W4.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C4: .01uf; C_Rect_L10.3mm_W4.5mm_P7.50mm_MKS4
R1: 300R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 18K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 1.1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 4.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 39K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: LM1815; SOIC-14_W3.9mm
U2: DIP8; DIP-8_W10.16mm

Connections:
5Volt: C3.1, R4.1, R5.1, U1.8, U2.5
unnamed: C1.1, R2.1, U1.3
unnamed: C2.1, R3.1, U1.7
unnamed: C4.1, R5.2, U1.14
unnamed: R4.2, R6.2, U1.12
VR+: R1.1, R2.2, U2.3
VR-: C1.2, C2.2, C3.2, C4.2, R1.2, R3.2, U1.2, U1.9, U1.11, U2.1, U2.2
Vout: R6.1, U2.7

Board: 2 copper layers, 26.7 x 26.7 mm, 12 parts (0 on the bottom side), 8 nets.

## KiCad design KiCad Files/Dual Opto Board/Speeduino Dual Opto Board.kicad_pcb

Parts:
J1: Conn_02x04_Counter_Clockwise; DIP-8_W7.62mm
Q1, Q2: ZTX450; TO-92_Inline_Wide; MPN ZTX450; Digi-Key_PN ZTX450-ND
R1, R2: 390R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4, R5, R6: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: ILD1; DIP-8_W7.62mm; MPN ILD207T; Digi-Key_PN 751-1310-1-ND

Connections:
+5V: J1.5, Q1.3 (C), Q2.3 (C), R1.1, R2.2, U1.6, U1.7
CKP: J1.1, U1.2
CKP-CPU: J1.8, Q1.1 (E), R3.1, R5.2
CMP: J1.4, U1.3
CMP-CPU: J1.7, Q2.1 (E), R4.1, R6.2
GND: J1.6, R5.1, R6.1
unnamed: Q1.2 (B), R3.2, U1.8
unnamed: Q2.2 (B), R4.2, U1.5
unnamed: R1.2, U1.1
unnamed: R2.1, U1.4

Notes on the sheet:
Crankshaft Position Sensor (open collector gear tooth sensor)
Goes High On Trigger
Camshaft Position Sensor (open collector gear tooth sensor)
Speeduino v0.4 IC3 plug
Speeduino IC3 socket pinout
Pin 1 = VR1-
Pin 2 = JP2 pin 3
Pin 3 = JP3 pin 1
Pin 4 = VR2-
Pin 5 = +5V
Pin 6 = Gnd
Pin 7 = Tach2-CPU-D18
Pin 8 = Tach1-CPU-D19
ILD1 vf = 1.1 @ 10ma

Board: 2 copper layers, 27.2 x 31.2 mm, 10 parts (0 on the bottom side), 10 nets.

## Commit log

2022-11-15 Create Git Hold
